## src/isa/riscv32/Kconfig
```kconfig
menu "ISA-dependent Options for riscv"

config RV64
  bool "64-bit RISC-V architecture"
  default y

config RVE
  bool "Use E extension"
  default n
endmenu
```
